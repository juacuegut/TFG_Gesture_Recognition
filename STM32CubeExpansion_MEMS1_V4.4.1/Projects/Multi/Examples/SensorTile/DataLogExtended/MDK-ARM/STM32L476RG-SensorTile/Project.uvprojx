# Keil uVision project Project.uvprojx, settings and files
target SensorTile-DataLogExtendeed (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32L476RG STMicroelectronics
  pack: Keil.STM32L4xx_DFP.1.4.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x18000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: DataLogExtended +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=.\STM32L476RG\@L.bin !L
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 wLevel=2
  c define: STM32L476xx,USE_HAL_DRIVER,USE_USB_FS,USE_SENSORTILE
  c misc: --no_conditionalize
  c include: ..\..\Inc;..\..\..\..\..\..\..\Drivers\BSP\Components\Common;..\..\..\..\..\..\..\Drivers\BSP\Components\hts221;..\..\..\..\..\..\..\Drivers\BSP\Components\lps22hb;..\..\..\..\..\..\..\Drivers\BSP\Components\lsm303agr;..\..\..\..\..\..\..\Drivers\BSP\Components\lsm6dsm;..\..\..\..\..\..\..\Drivers\BSP\SensorTile;..\..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L4xx\Include;..\..\..\..\..\..\..\Drivers\CMSIS\Include;..\..\..\..\..\..\..\Drivers\STM32L4xx_HAL_Driver\Inc;..\..\..\..\..\..\..\Middlewares\ST\STM32_USB_Device_Library\Class\CDC\Inc;..\..\..\..\..\..\..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  link misc: --diag_suppress=L6329
  group Drivers/BSP/Components
    ../../../../../../../Drivers/BSP/Components/hts221/: HTS221_Driver.c HTS221_Driver_HL.c
    ../../../../../../../Drivers/BSP/Components/lps22hb/: LPS22HB_Driver.c LPS22HB_Driver_HL.c
    ../../../../../../../Drivers/BSP/Components/lsm6dsm/: LSM6DSM_ACC_GYRO_driver.c LSM6DSM_ACC_GYRO_driver_HL.c
    ../../../../../../../Drivers/BSP/Components/lsm303agr/: LSM303AGR_ACC_driver.c LSM303AGR_ACC_driver_HL.c LSM303AGR_MAG_driver.c LSM303AGR_MAG_driver_HL.c
  group Drivers/BSP/SensorTile
    ../../../../../../../Drivers/BSP/SensorTile/: SensorTile.c SensorTile_accelero.c SensorTile_gyro.c SensorTile_humidity.c SensorTile_magneto.c SensorTile_pressure.c SensorTile_temperature.c
  group Drivers/CMSIS
    ../../Src/: system_stm32l4xx.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_cortex.c stm32l4xx_hal_gpio.c stm32l4xx_hal_i2c.c stm32l4xx_hal_pwr.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_ll_usb.c stm32l4xx_hal_pcd.c stm32l4xx_hal_pcd_ex.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rtc.c stm32l4xx_hal_dma.c stm32l4xx_hal_rtc_ex.c
  group Example/MDK-ARM
    ./: startup_stm32l476xx.s
  group Example/User
    ../../Src/: cube_hal_l4.c DemoSerial.c main.c sensor_commands.c serial_protocol.c stm32l4xx_hal_msp.c stm32l4xx_it.c usbd_cdc_interface.c usbd_conf.c usbd_desc.c vcom.c
  group Middlewares/STM32_USBD_Library/Core
    ../../../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
  group Middlewares/STM32_USBD_Library/Class/CDC
    ../../../../../../../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
